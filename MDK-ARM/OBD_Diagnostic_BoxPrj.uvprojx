# Keil uVision project OBD_Diagnostic_BoxPrj.uvprojx, settings and files
target OBD_Diagnostic_BoxPrj (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OBD_Diagnostic_BoxPrj +hex
  AfterMake: D:\Program Files\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  OBD_Diagnostic_BoxPrj\OBD_Diagnostic_BoxPrj.bin OBD_Diagnostic_BoxPrj\OBD_Diagnostic_BoxPrj.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Function/CAN;../Function/LED;../Function/USART;../Middlewares/Third_Party/FatFs/src;..\Function\LoopList;..\Application\LoopList;..\Application\USART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Function/User
    ../Function/LED/: fml_led.c
    ../Function/USART/: fml_usart.c
    ../Function/CAN/: fml_can.c
    ../Function/LoopList/: fml_looplist.c
  group Application/User
    ../Src/: main.c bsp_driver_sd.c sd_diskio.c fatfs.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../Application/LoopList/: app_looplist.c
    ../Application/USART/: app_usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
software components: CMSIS:CORE 4.3.0
